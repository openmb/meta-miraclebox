require miraclebox-blindscan-utils.inc

