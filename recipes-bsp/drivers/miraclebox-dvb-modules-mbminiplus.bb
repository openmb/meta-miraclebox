KV = "3.14.2"
SRCDATE = "20160122"

SRC_URI[md5sum] = "0fdcd091fc5657b14fa953e28aca6f5f"
SRC_URI[sha256sum] = "f664e8503e463fc0a2201f0596eab3fca7a3c1fe5faf8e91cd2a8d26b977c27c"

SRC_URI = "http://source.mynonpublic.com/ini/ini-422sv-drivers-${KV}-${SRCDATE}.zip"

require miraclebox-dvb-modules.inc

