KV = "3.6.0"
SRCDATE = "20160125"

SRC_URI[md5sum] = "b26afc5dcf01cae27db27bc9f0ab02ce"
SRC_URI[sha256sum] = "5736bec09ef68014c94837f3ebabb96d2d0a492d58e3d6e58c747610a5084411"

SRC_URI = "http://source.mynonpublic.com/ini/ini-x000-drivers-${KV}-${SRCDATE}.zip"

require miraclebox-dvb-modules.inc