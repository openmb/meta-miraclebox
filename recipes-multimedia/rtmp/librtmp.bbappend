PROVIDES =+ " librtmp1"
PACKAGES =+ " librtmp1"
