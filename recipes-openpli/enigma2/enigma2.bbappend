SRC_URI = "git://github.com/openmb/stb-gui.git;protocol=git;branch=${ENIGMA2_BRANCH}" 
