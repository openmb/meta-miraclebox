ENIGMA2_PLUGINS += " \
	enigma2-plugin-extensions-ppanel \
	\
	enigma2-plugin-pli-softcamsetup \
	enigma2-plugin-softcams-cccam \
	enigma2-plugin-softcams-mgcamd \
	enigma2-plugin-systemplugins-crossepg \
	"
