ENIGMA2_OPTIONAL += " \
	enigma2-plugin-extensions-oscamsmartcard \
	"
